# Keil uVision project lib_lpcusblib_13xx.uvproj, settings and files
target LPC1347_Device (ARM-ADS)
  device: LPC1347 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20000000-0x200007FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPCUSBlib_LPC1347_Device (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC1347__ CORE_M3 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\lpc_core\lpc_chip\chip_13xx;..\..\..\lpc_core\lpc_chip\chip_common;..\..\..\lpc_core\lpc_ip;..\..\..\CMSIS;..\..\..\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  group Class
    ../../Drivers/USB/Class/Common/: HIDParser.c
    ../../Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
    ../../Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c
  group Core
    ../../Drivers/USB/Core/: ConfigDescriptor.c Device.c DeviceStandardReq.c Endpoint.c EndpointStream.c Events.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
  group HAL
    ../../Drivers/USB/Core/HAL/LPC11UXX/: HAL_LPC11Uxx.c
    ../../Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ../../Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
  group HCD
    ../../Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../Drivers/USB/Core/HCD/OHCI/: OHCI.c
    ../../Drivers/USB/Core/HCD/: HCD.c
  group DCD
    ../../Drivers/USB/Core/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ../../Drivers/USB/Core/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ../../Drivers/USB/Core/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ../../Drivers/USB/Core/DCD/USBRom/: usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c usbd_adcuser.c
  group Config
    ../../: LPCUSBlibConfig.h
