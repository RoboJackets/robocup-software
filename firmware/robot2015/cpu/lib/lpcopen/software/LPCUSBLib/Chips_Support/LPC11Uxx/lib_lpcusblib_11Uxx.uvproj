# Keil uVision project lib_lpcusblib_11Uxx.uvproj, settings and files
target LPC11U1x_Device (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPCUSBlib_LPC11U1x_Device (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC11U1X__ CORE_M0 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\lpc_core\lpc_chip\chip_common;..\..\..\lpc_core\lpc_chip\chip_11xx;..\..\..\lpc_core\lpc_ip;..\..\..\CMSIS;..\..\..\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Class
    ../../Drivers/USB/Class/Common/: HIDParser.c
    ../../Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
    ../../Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c
  group Core
    ../../Drivers/USB/Core/: ConfigDescriptor.c Device.c DeviceStandardReq.c Endpoint.c EndpointStream.c Events.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
  group HAL
    ../../Drivers/USB/Core/HAL/LPC11UXX/: HAL_LPC11Uxx.c
    ../../Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ../../Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
  group HCD
    ../../Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../Drivers/USB/Core/HCD/OHCI/: OHCI.c
    ../../Drivers/USB/Core/HCD/: HCD.c
  group DCD
    ../../Drivers/USB/Core/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ../../Drivers/USB/Core/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ../../Drivers/USB/Core/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ../../Drivers/USB/Core/DCD/USBRom/: usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c usbd_adcuser.c
  group Config
    ../../: LPCUSBlibConfig.h
target LPC11U2x_3x_Device (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPCUSBlib_LPC11U2x_3x_Device (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC11U2X_3X__ CORE_M0 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
