# Keil uVision project lib_lpcusblib_18xx_43xx.uvproj, settings and files
target LPC18xx_Device (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPCUSBlib_LPC18xx_Device (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC18XX__ CORE_M3 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\lpc_core\lpc_chip\chip_common;..\..\..\lpc_core\lpc_ip;..\..\..\CMSIS;..\..\..\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Class
    ../../Drivers/USB/Class/Common/: HIDParser.c
    ../../Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
    ../../Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c
  group Core
    ../../Drivers/USB/Core/: ConfigDescriptor.c Device.c DeviceStandardReq.c Endpoint.c EndpointStream.c Events.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
  group HAL
    ../../Drivers/USB/Core/HAL/LPC11UXX/: HAL_LPC11Uxx.c
    ../../Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ../../Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
  group HCD
    ../../Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../Drivers/USB/Core/HCD/OHCI/: OHCI.c
    ../../Drivers/USB/Core/HCD/: HCD.c
  group DCD
    ../../Drivers/USB/Core/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ../../Drivers/USB/Core/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ../../Drivers/USB/Core/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ../../Drivers/USB/Core/DCD/USBRom/: usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c usbd_adcuser.c
  group Config
    ../../: LPCUSBlibConfig.h
target LPC18xx_Host (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC18xx_Host (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC18XX__ CORE_M3 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC18xx_HostDevice (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC18xx_HostDevice (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC18XX__ CORE_M3
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC43xx_Device (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: LPCUSBlib_LPC43xx_Device (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\lpc_core\lpc_chip\chip_common;..\..\..\lpc_core\lpc_ip;..\..\..\CMSIS;..\..\..\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC43xx_Host (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC43xx_Host (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC43xx_HostDevice (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC43xx_HostDevice (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4
  c misc: --gnu --c99 --diag_suppress=1207
  c include: as above
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC43xx_Device_m0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: LPCUSBlib_LPC43xx_Device_m0 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M0 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
