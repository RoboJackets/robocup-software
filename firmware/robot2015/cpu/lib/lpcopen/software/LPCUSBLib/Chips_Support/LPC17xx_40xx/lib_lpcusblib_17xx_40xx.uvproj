# Keil uVision project lib_lpcusblib_17xx_40xx.uvproj, settings and files
target LPC175x_6x_Device (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPCUSBlib_LPC175x_6x_Device (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC175X_6X__ CORE_M3 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\lpc_core\lpc_chip\chip_common;..\..\..\lpc_core\lpc_ip;..\..\..\CMSIS;..\..\..\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Class
    ../../Drivers/USB/Class/Common/: HIDParser.c
    ../../Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
    ../../Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c
  group Core
    ../../Drivers/USB/Core/: ConfigDescriptor.c Device.c DeviceStandardReq.c Endpoint.c EndpointStream.c Events.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
  group HAL
    ../../Drivers/USB/Core/HAL/LPC11UXX/: HAL_LPC11Uxx.c
    ../../Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ../../Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
  group HCD
    ../../Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../Drivers/USB/Core/HCD/OHCI/: OHCI.c
    ../../Drivers/USB/Core/HCD/: HCD.c
  group DCD
    ../../Drivers/USB/Core/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ../../Drivers/USB/Core/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ../../Drivers/USB/Core/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ../../Drivers/USB/Core/DCD/USBRom/: usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c usbd_adcuser.c
  group Config
    ../../: LPCUSBlibConfig.h
target LPC175x_6x_Host (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC175x_6x_Host (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC175X_6X__ CORE_M3 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC177x_8x_Device (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPCUSBlib_LPC177x_8x_Device (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC177X_8X__ CORE_M3 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\lpc_core\lpc_chip\chip_common;..\..\..\lpc_core\lpc_ip;..\..\..\CMSIS;..\..\..\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target LPC177x_8x_Host (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC177x_8x_Host (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC177X_8X__ CORE_M3 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target LPC407x_8x_Device (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: LPCUSBlib_LPC407x_8x_Device (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC407X_8X__ CORE_M4 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\lpc_core\lpc_chip\chip_common;..\..\..\lpc_core\lpc_ip;..\..\..\CMSIS;..\..\..\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target LPC407x_8x_Host (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC407x_8x_Host (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC407X_8X__ CORE_M4 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
