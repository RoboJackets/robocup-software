# Keil uVision project lib_lpc_boards_11xx.uvproj, settings and files
target nxp_xpresso_11u14 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: board_nxp_xpresso_11u14 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\lpc_ip;..\..\lpc_chip\chip_11xx;..\board_common;.\nxp_xpresso_11u14;..\..\lpc_chip\chip_common;..\..\..\CMSIS
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group board_nxp_xpresso_11u14
    ./nxp_xpresso_11u14/: board_nxp_xpresso_11u14.c sysinit_nxp_xpresso_11u14.c
  group board_nxp_xpresso_11c24
    ./nxp_xpresso_11c24/: board_nxp_xpresso_11c24.c sysinit_nxp_xpresso_11c24.c
  group chip_11xx
    ../../lpc_chip/chip_11xx/: acmp_11xx.c adc_11xx.c clock_11xx.c gpio_11xx.c i2c_11xx.c iocon_11xx.c ssp_11xx.c sysctl_11xx.c timer_11xx.c uart_11xx.c wwdt_11xx.c
    ../../lpc_chip/chip_common/: ring_buffer.c
  group ip
    ../../lpc_ip/: acmp_001.c adc_001.c dac_001.c gpiogrpint_001.c gpiopinint_001.c i2c_001.c ssp_001.c timer_001.c wwdt_001.c gpio_003.c usart_004.c
target nxp_xpresso_11c24 (ARM-ADS)
  device: LPC11C24/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: board_nxp_xpresso_11c24 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\lpc_ip;..\..\lpc_chip\chip_11xx;..\board_common;.\nxp_xpresso_11c24;..\..\lpc_chip\chip_common;..\..\..\CMSIS
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
