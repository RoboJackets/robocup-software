# Keil uVision project lib_lpc_boards_8xx.uvproj, settings and files
target nxp_xpresso_812 (ARM-ADS)
  device: LPC812M101 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: board_nxp_xpresso_812 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\software\lpc_core\lpc_chip\chip_8xx;..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\software\lpc_core\lpc_board\boards_8xx\nxp_xpresso_812;..\..\..\..\software\CMSIS
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group board_nxp_xpresso_812
    ../../../../software/lpc_core/lpc_board/boards_8xx/nxp_xpresso_812/: board_nxp_xpresso_812.c sysinit_nxp_xpresso_812.c
  group chip_8xx
    ../../../../software/lpc_core/lpc_chip/chip_8xx/: acmp_8xx.c clock_8xx.c crc_8xx.c gpio_8xx.c i2c_8xx.c iocon_8xx.c pinint_8xx.c pmu_8xx.c sct_8xx.c spi_8xx.c swm_8xx.c syscon_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c
  group ip
    ../../../../software/lpc_core/lpc_ip/: acmp_001.c crc_001.c sct_001.c spi_002.c usart_002.c wwdt_001.c
