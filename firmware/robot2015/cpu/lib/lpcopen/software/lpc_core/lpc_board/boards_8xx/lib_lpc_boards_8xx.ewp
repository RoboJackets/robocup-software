# IAR project lib_lpc_boards_8xx.ewp, settings and files
configuration nxp_xpresso_812 (ARM)
  General.OGChipSelectEditMenu: LPC812M101 NXP LPC812M101
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_8xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_8xx\nxp_xpresso_812; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_nxp_xpresso_812
    nxp_xpresso_812/: board_nxp_xpresso_812.c sysinit_nxp_xpresso_812.c
  group chip_8xx
    ../../lpc_chip/chip_8xx/: acmp_8xx.c clock_8xx.c crc_8xx.c gpio_8xx.c i2c_8xx.c iocon_8xx.c pinint_8xx.c pmu_8xx.c sct_8xx.c spi_8xx.c swm_8xx.c syscon_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c
  group ip
    ../../lpc_ip/: acmp_001.c crc_001.c sct_001.c spi_002.c usart_002.c wwdt_001.c
