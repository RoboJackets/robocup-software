# IAR project lib_lpc_boards_11xx.ewp, settings and files
configuration nxp_xpresso_11u14 (ARM)
  General.OGChipSelectEditMenu: LPC11U14FBD48_201 NXP LPC11U14FBD48_201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_11xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_11xx\nxp_xpresso_11u14; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
configuration nxp_xpresso_11c24 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC11C24FBD48_301 NXP LPC11C24FBD48_301
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_11xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_11xx\nxp_xpresso_11c24; ..\..\..\CMSIS\CMSIS\Include
  group board_nxp_xpresso_11c24
    nxp_xpresso_11c24/: board_nxp_xpresso_11c24.c sysinit_nxp_xpresso_11c24.c
  group board_nxp_xpresso_11u14
    nxp_xpresso_11u14/: board_nxp_xpresso_11u14.c sysinit_nxp_xpresso_11u14.c
  group chip_11xx
    ../../lpc_chip/chip_11xx/: adc_11xx.c clock_11xx.c gpio_11xx.c i2c_11xx.c iocon_11xx.c ssp_11xx.c sysctl_11xx.c timer_11xx.c uart_11xx.c wwdt_11xx.c
    ../../lpc_chip/chip_common/: ring_buffer.c
  group ip
    ../../lpc_ip/: adc_001.c gpio_003.c gpiogrpint_001.c gpiopinint_001.c i2c_001.c ssp_001.c timer_001.c usart_004.c wwdt_001.c
