# Keil uVision project lib_lpc_boards_13xx.uvproj, settings and files
target nxp_xpresso_1347 (ARM-ADS)
  device: LPC1347 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20000000-0x200007FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: board_nxp_xpresso_1347 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\lpc_ip;..\..\lpc_chip\chip_13xx;..\board_common;.\nxp_xpresso_1347;..\..\lpc_chip\chip_common;..\..\..\CMSIS
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  group board_nxp_xpresso_1343
    ./nxp_xpresso_1343/: board_nxp_xpresso_1343.c sysinit_nxp_xpresso_1343.c
  group board_nxp_xpresso_1347
    ./nxp_xpresso_1347/: board_nxp_xpresso_1347.c sysinit_nxp_xpresso_1347.c
  group chip_13xx
    ../../lpc_chip/chip_13xx/: adc_13xx.c clock_13xx.c gpio_13xx.c iocon_13xx.c sysctl_13xx.c timer_13xx.c uart_13xx.c wwdt_13xx.c ritimer_13xx.c ssp_13xx.c i2c_13xx.c flash_13xx.c
    ../../lpc_chip/chip_common/: ring_buffer.c
  group ip
    ../../lpc_ip/: adc_001.c gpiogrpint_001.c gpiopinint_001.c i2c_001.c ssp_001.c timer_001.c wwdt_001.c gpio_003.c gpio_003.c usart_004.c ritimer_001.c
target nxp_xpresso_1343 (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: board_nxp_xpresso_1343 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\lpc_ip;..\..\lpc_chip\chip_13xx;..\board_common;.\nxp_xpresso_1343;..\..\lpc_chip\chip_common;..\..\..\CMSIS
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
