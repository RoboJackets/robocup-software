# Keil uVision project lib_lpc_boards_17xx_40xx.uvproj, settings and files
target ea_devkit_1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: board_ea_devkit_1788 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\lpc_ip;..\..\lpc_chip\chip_17xx_40xx;..\board_common;.\ea_devkit_17884088\ea_devkit_1788;..\..\lpc_chip\chip_common;..\..\..\CMSIS;.\ea_devkit_17884088
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group ip
    ../../lpc_ip/: adc_001.c emc_001.c fpu_init.c gpdma_001.c timer_001.c usart_001.c dac_001.c ssp_001.c rtc_001.c i2c_001.c lcd_001.c i2s_001.c eeprom_001.c can_001.c crc_001.c enet_002.c sdc_001.c wwdt_001.c ritimer_001.c
  group chip_17xx_40xx
    ../../lpc_chip/chip_17xx_40xx/: adc_17xx_40xx.c uart_17xx_40xx.c gpdma_17xx_40xx.c emc_17xx_40xx.c ssp_17xx_40xx.c rtc_17xx_40xx.c i2c_17xx_40xx.c lcd_17xx_40xx.c i2s_17xx_40xx.c dac_17xx_40xx.c timer_17xx_40xx.c eeprom_17xx_40xx.c can_17xx_40xx.c crc_17xx_40xx.c enet_17xx_40xx.c sdc_17xx_40xx.c wwdt_17xx_40xx.c cmp_17xx_40xx.c clock_17xx_40xx.c sysctl_17xx_40xx.c ritimer_17xx_40xx.c spi_17xx_40xx.c iocon_17xx_40xx.c sdmmc_17xx_40xx.c
    ../../lpc_chip/chip_common/: mem_tests.c
  group board_ea_devkit_1788
    ./ea_devkit_17884088/: board_ea_devkit_17884088.c sysinit_ea_devkit_17884088.c
    ../board_common/: uda1380.c
  group board_nxp_xpresso_1769
    ./nxp_xpresso_1769/: board_nxp_xpresso_1769.c sysinit_nxp_xpresso_1769.c
target ea_devkit_4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: board_ea_devkit_4088 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\lpc_ip;..\..\lpc_chip\chip_17xx_40xx;..\board_common;.\ea_devkit_17884088\ea_devkit_4088;..\..\lpc_chip\chip_common;..\..\..\CMSIS;.\ea_devkit_17884088
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target nxp_xpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: board_nxp_xpresso_1769 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\lpc_ip;..\..\lpc_chip\chip_17xx_40xx;..\board_common;.\nxp_xpresso_1769;..\..\lpc_chip\chip_common;..\..\..\CMSIS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
