# IAR project lpcusblib_MassStorageDevice.ewp, settings and files
configuration iflash_ea_devkit_1788 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; __LPC177X_8X__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB; ..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice\sdmmc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  OBJCOPY.OOCOutputFile: lpcusblib_MassStorageDevice.srec
  ILINK.IlinkOutputFile: MassStorageDevice_iflash_ea_devkit_1788.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration iflash_ea_devkit_4088 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4; __LPC407X_8X__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB; ..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice\sdmmc
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  ILINK.IlinkOutputFile: MassStorageDevice_iflash_ea_devkit_4088.out
configuration iflash_nxp_xpresso_1769 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  ICCARM.CCDefines: CORE_M3; __LPC175X_6X__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB; ..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice\sdmmc
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_1788/Exe/: board_ea_devkit_1788.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_4088/Exe/: board_ea_devkit_4088.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/nxp_xpresso_1769/Exe/: board_nxp_xpresso_1769.a
    ../../../../../software/LPCUSBLib/Chips_Support/LPC17xx_40xx/iar_output/LPC175x_6x_Device/Exe/: LPCUSBlib_LPC175x_6x_Device.a
    ../../../../../software/LPCUSBLib/Chips_Support/LPC17xx_40xx/iar_output/LPC177x_8x_Device/Exe/: LPCUSBlib_LPC177x_8x_Device.a
    ../../../../../software/LPCUSBLib/Chips_Support/LPC17xx_40xx/iar_output/LPC407x_8x_Device/Exe/: LPCUSBlib_LPC407x_8x_Device.a
  group src
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: DataRam.c fatutil.c SCSI.c
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: Descriptors.c MassStorage.c
    ../../../startup_code/: iar_startup_lpc17xx_40xx.s
