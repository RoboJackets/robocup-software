# Keil uVision project periph_ritimer.uvproj, settings and files
target iflash_nxp_xpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ritimer_iflash_nxp_xpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./: ritimer.c
    ../../../startup_code/: keil_startup_lpc17xx_40xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/nxp_xpresso_1769/: board_nxp_xpresso_1769.lib
