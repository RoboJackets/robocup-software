# Keil uVision project ucos_iii_blinky.uvproj, settings and files
target iflash_ea_devkit_1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ucos_iii_blinky_iflash_ea_devkit_1788
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M3\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ../startup_code/: keil_ucos_iii_startup_lpc17xx_40xx.s
    ./: ucos_iii_blinky.c
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_1788/: board_ea_devkit_1788.lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_4088/: board_ea_devkit_4088.lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/nxp_xpresso_1769/: board_nxp_xpresso_1769.lib
  group ucos_iii_17xx
    ../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s
    ../../../../../software/ucos_iii/Micrium/Software/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm
  group ucos_iii_40xx
    ../../../../../software/ucos_iii/Micrium/Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm
    ../../../../../software/ucos_iii/lpc_ucos_iii/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group ucos_iii
    ../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Source/: os_var.c os_tmr.c os_time.c os_tick.c os_task.c os_stat.c os_sem.c os_q.c os_prio.c os_pend_multi.c os_mutex.c os_msg.c os_mem.c os_int.c os_flag.c os_dbg.c os_core.c os_cfg_app.c
    ../../../../../software/ucos_iii/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../../../software/ucos_iii/lpc_ucos_iii/lpc17xx40xx_bsp/: cpu_bsp.c
target iflash_ea_devkit_4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: ucos_iii_blinky_iflash_ea_devkit_4088
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M4\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  asm define: CORE_M4
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target iflash_nxp_xpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ucos_iii_blinky_iflash_nxp_xpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M3\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
