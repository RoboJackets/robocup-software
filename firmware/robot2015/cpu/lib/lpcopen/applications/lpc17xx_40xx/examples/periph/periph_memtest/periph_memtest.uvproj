# Keil uVision project periph_memtest.uvproj, settings and files
target iram_ea_devkit_1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: memtest_iram_ea_devkit_1788 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./: memtest.c
    ../../../startup_code/: keil_startup_lpc17xx_40xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_1788/: board_ea_devkit_1788.lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_4088/: board_ea_devkit_4088.lib
target iram_ea_devkit_4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: memtest_iram_ea_devkit_4088 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088
  asm define: CORE_M4
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
