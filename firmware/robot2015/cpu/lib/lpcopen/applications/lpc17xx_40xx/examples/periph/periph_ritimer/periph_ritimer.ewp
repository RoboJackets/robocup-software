# IAR project periph_ritimer.ewp, settings and files
configuration iflash_nxp_xpresso_1769 (ARM)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769
  OBJCOPY.OOCOutputFile: periph_ritimer.bin
  ILINK.IlinkOutputFile: ritimer_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_1788/Exe/: board_ea_devkit_1788.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_4088/Exe/: board_ea_devkit_4088.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/nxp_xpresso_1769/Exe/: board_nxp_xpresso_1769.a
  group src
    ../../../startup_code/: iar_startup_lpc17xx_40xx.s
    ./: ritimer.c
