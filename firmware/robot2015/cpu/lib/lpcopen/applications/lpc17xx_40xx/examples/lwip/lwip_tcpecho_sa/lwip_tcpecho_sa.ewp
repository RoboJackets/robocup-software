# IAR project lwip_tcpecho_sa.ewp, settings and files
configuration iflash_ea_devkit_1788 (ARM)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788; ..\..\..\..\..\software\CMSIS\CMSIS\Include; $PROJ_DIR$; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  OBJCOPY.OOCOutputFile: lwip_tcpecho_sa.bin
  ILINK.IlinkOutputFile: lwip_tcpecho_sa_$CONFIG_NAME$.out
  ILINK.IlinkIcfFile: linkerscripts\lpc178x_408x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iflash_ea_devkit_4088 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
configuration iflash_nxp_xpresso_1769 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769; ..\..\..\..\..\software\CMSIS\CMSIS\Include; $PROJ_DIR$; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769
  ILINK.IlinkIcfFile: linkerscripts\lpc176x.icf
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_1788/Exe/: board_ea_devkit_1788.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_4088/Exe/: board_ea_devkit_4088.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/nxp_xpresso_1769/Exe/: board_nxp_xpresso_1769.a
  group lpclwip
    ../../../../../software/lwip/lpclwip/arch/: lpc17xx_40xx_emac.c lpc17xx_40xx_systick_arch.c lpc_debug.c
  group lwip
    ../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../software/lwip/lwip/src/netif/: etharp.c
  group src
    ../../../../../software/lwip/contrib/apps/tcpecho_raw/: echo.c
    ../../../startup_code/: iar_startup_lpc17xx_40xx.s
    ./: lwip_tcpecho_sa.c
