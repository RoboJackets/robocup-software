# Keil uVision project lpcusblib_MassStorageHost.uvproj, settings and files
target iflash_nxp_xpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MassStorageHost_iflash_nxp_xpresso_1769 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC175X_6X__ CORE_M3 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\applications\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group fatfs
    ../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../software/filesystems/fatfslpc/: fs_usb.c rtc.c
  group src
    ../../../../LPCUSBlib/lpcusblib_MassStorageHost/: MassStorageHost.c
    ../../../startup_code/: keil_startup_lpc17xx_40xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/nxp_xpresso_1769/: board_nxp_xpresso_1769.lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_1788/: board_ea_devkit_1788.lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_4088/: board_ea_devkit_4088.lib
    ../../../../../software/LPCUSBLib/Chips_Support/LPC17xx_40xx/keil_output/LPCUSBlib_LPC175x_6x_Host/: LPCUSBlib_LPC175x_6x_Host.lib
    ../../../../../software/LPCUSBLib/Chips_Support/LPC17xx_40xx/keil_output/LPCUSBlib_LPC177x_8x_Host/: LPCUSBlib_LPC177x_8x_Host.lib
    ../../../../../software/LPCUSBLib/Chips_Support/LPC17xx_40xx/keil_output/LPCUSBlib_LPC407x_8x_Host/: LPCUSBlib_LPC407x_8x_Host.lib
target iflash_ea_devkit_1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MassStorageHost_iflash_ea_devkit_1788 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC177X_8X__ CORE_M3 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\applications\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\tool_configs\keil_ini_files\LPC177x_8x.sct
target iflash_ea_devkit_4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: MassStorageHost_iflash_ea_devkit_4088 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC407X_8X__ CORE_M4 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\applications\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP CORE_M4
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\tool_configs\keil_ini_files\LPC177x_8x.sct
