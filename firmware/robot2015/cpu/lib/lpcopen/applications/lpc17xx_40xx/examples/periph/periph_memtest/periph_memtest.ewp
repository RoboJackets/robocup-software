# IAR project periph_memtest.ewp, settings and files
configuration iram_ea_devkit_1788 (ARM)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  OBJCOPY.OOCOutputFile: periph_memtest.bin
  ILINK.IlinkOutputFile: memtest_$CONFIG_NAME$.out
  ILINK.IlinkIcfFile: ..\..\..\tool_configs\iar_linker_scripts\LPC178x_408x_iram
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iram_ea_devkit_4088 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_1788/Exe/: board_ea_devkit_1788.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_4088/Exe/: board_ea_devkit_4088.a
  group src
    ../../../startup_code/: iar_startup_lpc17xx_40xx.s
    ./: memtest.c
