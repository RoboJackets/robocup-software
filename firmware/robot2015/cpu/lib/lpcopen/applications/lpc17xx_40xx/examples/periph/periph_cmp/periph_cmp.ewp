# IAR project periph_cmp.ewp, settings and files
configuration iflash_ea_devkit_4088 (ARM)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  OBJCOPY.OOCOutputFile: periph_cmp.bin
  ILINK.IlinkOutputFile: cmp_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_1788/Exe/: board_ea_devkit_1788.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_4088/Exe/: board_ea_devkit_4088.a
  group src
    ./: cmp.c
    ../../../startup_code/: iar_startup_lpc17xx_40xx.s
