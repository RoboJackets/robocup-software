# Keil uVision project swim_color_bars.uvproj, settings and files
target iflash_ea_devkit_1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: swim_colorbars_iflash_ea_devkit_1788
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3 COLORS_DEF=16
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\swim
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./: swim_color_bars.c
    ../../../startup_code/: keil_startup_lpc17xx_40xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_1788/: board_ea_devkit_1788.lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_4088/: board_ea_devkit_4088.lib
  group swim
    ../../../../../software/swim/: lpc_colors.c lpc_fonts.c lpc_helvr10.c lpc_rom8x16.c lpc_rom8x8.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x6x13.c lpc_swim.c
target iflash_ea_devkit_4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: swim_clorbars_iflash_ea_devkit_4088
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4 COLORS_DEF=16
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\CMSIS;..\..\..\..\..\software\swim
  asm define: CORE_M4
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
