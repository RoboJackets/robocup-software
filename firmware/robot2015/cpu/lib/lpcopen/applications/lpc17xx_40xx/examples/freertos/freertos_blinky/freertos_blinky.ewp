# IAR project freertos_blinky.ewp, settings and files
configuration iflash_ea_devkit_1788 (ARM)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M3
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: freertos_blinky.bin
  ILINK.IlinkOutputFile: freertos_blinky_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iflash_ea_devkit_4088 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  AARM.ADefines: CORE_M4
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088; $PROJ_DIR$
configuration iflash_nxp_xpresso_1769 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769; $PROJ_DIR$
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
  group FreeRTOS_40xx
    ../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOS_lpc17xx
    ../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_1788/Exe/: board_ea_devkit_1788.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/ea_devkit_4088/Exe/: board_ea_devkit_4088.a
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/iar_output/nxp_xpresso_1769/Exe/: board_nxp_xpresso_1769.a
  group src
    ./: freertos_blinky.c
    ../startup_code/: iar_freertos_startup_lpc17xx40xx.s
