# Keil uVision project lwip_tcpecho_freertos.uvproj, settings and files
target iflash_ea_devkit_1788 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lwip_sa_iflash_ea_devkit_1788
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\lwip_tcpecho_freertos
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\linkerscripts\lpc178x_408x.sct
  group src
    ./: lwip_tcpecho_freertos.c
    ../../../../../software/lwip/contrib/apps/tcpecho/: tcpecho.c
    ../startup_code_freertos/: keil_freertos_startup_lpc17xx_40xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_1788/: board_ea_devkit_1788.lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/ea_devkit_4088/: board_ea_devkit_4088.lib
    ../../../../../software/lpc_core/lpc_board/boards_17xx_40xx/keil_output/nxp_xpresso_1769/: board_nxp_xpresso_1769.lib
  group FreeRTOS_17xx
    ../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_40xx
    ../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../software/freertos/freertos/Source/: croutine.c queue.c list.c tasks.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
  group LWIP
    ../../../../../software/lwip/lwip/src/core/: udp.c timers.c tcp_out.c tcp_in.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c dhcp.c def.c
    ../../../../../software/lwip/lwip/src/core/ipv4/: ip_frag.c ip_addr.c ip.c inet_chksum.c inet.c igmp.c icmp.c autoip.c
    ../../../../../software/lwip/lwip/src/netif/: etharp.c
    ../../../../../software/lwip/lwip/src/api/: tcpip.c sockets.c netifapi.c api_msg.c api_lib.c netdb.c err.c
  group lpclwip
    ../../../../../software/lwip/lpclwip/arch/: sys_arch_freertos.c lpc17xx_40xx_systick_arch.c lpc17xx_40xx_emac.c lpc_debug.c
    ../../../../../software/lwip/lwip/src/api/: netbuf.c
target iflash_ea_devkit_4088 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lwip_sa_iflash_ea_devkit_4088
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\lwip_tcpecho_freertos
  asm define: CORE_M4
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\linkerscripts\lpc178x_408x.sct
target iflash_nxp_xpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lwip_freertos_iflash_nxp_xpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\lwip_tcpecho_freertos
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_xpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
