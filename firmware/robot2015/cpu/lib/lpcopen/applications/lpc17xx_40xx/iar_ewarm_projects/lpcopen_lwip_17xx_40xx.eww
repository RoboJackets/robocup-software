<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\lib_lpc_boards_17xx_40xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\lwip\lwip_tcpecho_freertos\lwip_tcpecho_freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\lwip\lwip_tcpecho_sa\lwip_tcpecho_sa.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>lib_lpc_boards</name>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_1788</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_4088</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>lib_lpc_boards_and_Examples</name>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_1788</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_4088</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>lwip_tcpecho_freertos</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>lwip_tcpecho_freertos</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>lwip_tcpecho_freertos</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>lwip_tcpecho_sa</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>lwip_tcpecho_sa</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>lwip_tcpecho_sa</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>webserver</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>webserver</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>webserver</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


