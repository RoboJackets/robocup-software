<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\lib_lpc_boards_17xx_40xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\misc\periph_nandflash\periph_nandflash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\misc\periph_norflash\periph_norflash.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_board_libs</name>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_1788</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_4088</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>app_sdmmc_meas</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>app_sdmmc_meas</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_nandflash</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_nandflash</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_norflash</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_norflash</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


