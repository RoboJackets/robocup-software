<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\lib_lpc_boards_17xx_40xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\ucos_iii\ucos_iii_blinky\ucos_iii_blinky.ewp</path>
  </project>
  <batchBuild/>
</workspace>


