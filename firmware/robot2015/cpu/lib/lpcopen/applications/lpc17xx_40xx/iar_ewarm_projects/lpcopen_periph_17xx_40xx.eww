<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\lib_lpc_boards_17xx_40xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_adc\periph_adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_can\periph_can.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_cmp\periph_cmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_crc\periph_crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_dac\periph_dac.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_eeprom\periph_eeprom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ethernet\periph_ethernet.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_i2c\periph_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_i2s\periph_i2s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_lcd\periph_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_memtest\periph_memtest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ritimer\periph_ritimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_rtc\periph_rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_rtc_ev\periph_rtc_ev.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_sdmmc\periph_sdmmc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_spi\periph_spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ssp\periph_ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_uart\periph_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_watchdog\periph_watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_board_libs</name>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_1788</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_4088</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>nxp_xpresso_1769</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>All_libs_and_Examples</name>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_1788</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_can</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_can</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_cmp</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_crc</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_crc</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_dac</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_dac</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_eeprom</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_eeprom</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_lcd</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_lcd</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_memtest</project>
        <configuration>iram_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_memtest</project>
        <configuration>iram_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_rtc_ev</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_rtc_ev</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_sdmmc</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_sdmmc</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>iflash_ea_devkit_1788</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>iflash_ea_devkit_4088</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_17xx_40xx</project>
        <configuration>nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_can</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_dac</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_ritimer</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
      <member>
        <project>periph_spi</project>
        <configuration>iflash_nxp_xpresso_1769</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


