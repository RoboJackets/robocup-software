<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\lib_lpc_boards_17xx_40xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\software\LPCUSBLib\Chips_Support\LPC17xx_40xx\lib_lpcusblib_17xx_40xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_AudioInputDevice\lpcusblib_AudioInputDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_AudioOutputDevice\lpcusblib_AudioOutputDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_AudioOutputHost\lpcusblib_AudioOutputHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_GenericHIDDevice\lpcusblib_GenericHIDDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_KeyboardDevice\lpcusblib_KeyboardDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_KeyboardHost\lpcusblib_KeyboardHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_MassStorageDevice\lpcusblib_MassStorageDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_MassStorageHost\lpcusblib_MassStorageHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_MouseDevice\lpcusblib_MouseDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_VirtualSerialDevice\lpcusblib_VirtualSerialDevice.ewp</path>
  </project>
  <batchBuild/>
</workspace>


