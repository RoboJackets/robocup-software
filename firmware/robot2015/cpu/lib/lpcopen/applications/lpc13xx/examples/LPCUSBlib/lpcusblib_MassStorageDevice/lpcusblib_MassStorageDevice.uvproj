# Keil uVision project lpcusblib_MassStorageDevice.uvproj, settings and files
target iflash_nxp_xpresso_1347 (ARM-ADS)
  device: LPC1347 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20000000-0x200007FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MassStorage_iflash_nxp_xpresso_1347 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC1347__ CORE_M3 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_13xx;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice\sdmmc;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  group src
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: MassStorage.c Descriptors.c
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: SCSI.c fatutil.c DataRam.c
    ../../../startup_code/: keil_startup_lpc13xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_13xx/keil_output/nxp_xpresso_1347/: board_nxp_xpresso_1347.lib
    ../../../../../software/LPCUSBLib/Chips_Support/LPC13xx/keil_output/LPCUSBlib_LPC1347_Device/: LPCUSBlib_LPC1347_Device.lib
