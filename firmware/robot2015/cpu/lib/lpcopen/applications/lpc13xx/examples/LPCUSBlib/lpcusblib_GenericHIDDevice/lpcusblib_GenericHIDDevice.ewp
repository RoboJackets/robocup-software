# IAR project lpcusblib_GenericHIDDevice.ewp, settings and files
configuration iflash_nxp_xpresso_1347 (ARM)
  General.OGChipSelectEditMenu: LPC1347 NXP LPC1347
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; __LPC1347__; USB_DEVICE_ONLY
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_13xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBLib\Drivers\USB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347
  OBJCOPY.OOCOutputFile: lpcusblib_GenericHIDDevice.bin
  ILINK.IlinkOutputFile: Generic_HIDDevice_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_13xx/iar_output/nxp_xpresso_1347/Exe/: board_nxp_xpresso_1347.a
    ../../../../../software/LPCUSBLib/Chips_Support/LPC13xx/iar_output/LPC1347_Device/Exe/: LPCUSBlib_LPC1347_Device.a
  group src
    ../../../../LPCUSBlib/lpcusblib_GenericHIDDevice/: Descriptors.c GenericHID.c
    ../../../startup_code/: iar_startup_lpc13xx.s
    ../../../../LPCUSBlib/lpcusblib_GenericHIDDevice/Lib/: UsbRom.c
