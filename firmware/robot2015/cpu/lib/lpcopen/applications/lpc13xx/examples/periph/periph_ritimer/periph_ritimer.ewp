# IAR project periph_ritimer.ewp, settings and files
configuration iflash_nxp_xpresso_1347 (ARM)
  General.OGChipSelectEditMenu: LPC1347 NXP LPC1347
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_13xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347
  OBJCOPY.OOCOutputFile: periph_ritimer.bin
  ILINK.IlinkOutputFile: ritimer_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_13xx/iar_output/nxp_xpresso_1347/Exe/: board_nxp_xpresso_1347.a
  group src
    ../../../startup_code/: iar_startup_lpc13xx.s
    ./: ritimer.c
