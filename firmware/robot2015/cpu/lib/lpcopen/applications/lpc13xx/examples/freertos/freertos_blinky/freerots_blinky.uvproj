# Keil uVision project freerots_blinky.uvproj, settings and files
target iflash_nxp_xpresso_1347 (ARM-ADS)
  device: LPC1347 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20000000-0x200007FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: freertos_blinky_iflash_nxp_xpresso_1347
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_13xx;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\software\freertos\freertoslpc;..\freertos_blinky
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x800
  group src
    ./: freertos_blinky.c
    ../startup_code/: keil_freertos_startup_lpc13xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_13xx/keil_output/nxp_xpresso_1347/: board_nxp_xpresso_1347.lib
    ../../../../../software/lpc_core/lpc_board/boards_13xx/keil_output/nxp_xpresso_1343/: board_nxp_xpresso_1343.lib
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
target iflash_nxp_xpresso_1343 (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: freertos_blinky_iflash_nxp_xpresso_1343
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1343;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_13xx;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\software\freertos\freertoslpc;..\freertos_blinky
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1343
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
