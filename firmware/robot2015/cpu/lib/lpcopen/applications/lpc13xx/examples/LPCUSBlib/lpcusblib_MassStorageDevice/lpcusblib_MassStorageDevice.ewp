# IAR project lpcusblib_MassStorageDevice.ewp, settings and files
configuration iflash_nxp_xpresso_1347 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1347 NXP LPC1347
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; __LPC1347__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_13xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB; ..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice\sdmmc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347
  OBJCOPY.OOCOutputFile: lpcusblib_MassStorageDevice.srec
  prebuild: cmd /C /E:ON mkdir settings || cd
  ILINK.IlinkOutputFile: MassStorageDevice_spifi_ngx_xplorer_1830.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_13xx/iar_output/nxp_xpresso_1347/Exe/: board_nxp_xpresso_1347.a
    ../../../../../software/LPCUSBLib/Chips_Support/LPC13xx/iar_output/LPC1347_Device/Exe/: LPCUSBlib_LPC1347_Device.a
  group src
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: DataRam.c fatutil.c SCSI.c UsbRom.c
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: Descriptors.c MassStorage.c
    ../../../startup_code/: iar_startup_lpc13xx.s
