# IAR project freertos_blinky.ewp, settings and files
configuration iflash_nxp_xpresso_1347 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1347 NXP LPC1347
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_13xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: freertos_blinky.bin
  ILINK.IlinkOutputFile: freertos_blinky_iflash_nxp_xpresso_1347.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iflash_nxp_xpresso_1343 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_13xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1343; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1343; $PROJ_DIR$
  ILINK.IlinkOutputFile: freertos_blinky_iflash_nxp_xpresso_1343.out
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_2.c
    ../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_13xx/iar_output/nxp_xpresso_1343/Exe/: board_nxp_xpresso_1343.a
    ../../../../../software/lpc_core/lpc_board/boards_13xx/iar_output/nxp_xpresso_1347/Exe/: board_nxp_xpresso_1347.a
  group src
    ./: freertos_blinky.c
    ../startup_code/: iar_freertos_startup_lpc13xx.s
