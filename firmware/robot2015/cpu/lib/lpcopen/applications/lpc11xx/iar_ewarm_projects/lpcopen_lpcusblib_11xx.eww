<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_11xx\lib_lpc_boards_11xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\software\LPCUSBLib\Chips_Support\LPC11Uxx\lib_lpcusblib_11Uxx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_GenericHIDDevice\lpcusblib_GenericHIDDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_KeyboardDevice\lpcusblib_KeyboardDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_MassStorageDevice\lpcusblib_MassStorageDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_MouseDevice\lpcusblib_MouseDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_VirtualSerialDevice\lpcusblib_VirtualSerialDevice.ewp</path>
  </project>
  <batchBuild/>
</workspace>


