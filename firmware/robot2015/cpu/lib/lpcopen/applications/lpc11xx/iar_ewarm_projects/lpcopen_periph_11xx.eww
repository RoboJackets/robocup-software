<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_11xx\lib_lpc_boards_11xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_adc\periph_adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_bod\periph_bod.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ccan_rom\periph_ccan_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_clkout\periph_clkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_i2c\periph_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ssp\periph_ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_uart\periph_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_watchdog\periph_watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_board_libs</name>
      <member>
        <project>lib_lpc_boards_11xx</project>
        <configuration>nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_11xx</project>
        <configuration>nxp_xpresso_11u14</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>All_libs_and_Examples</name>
      <member>
        <project>lib_lpc_boards_11xx</project>
        <configuration>nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_11xx</project>
        <configuration>nxp_xpresso_11u14</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_nxp_xpresso_11u14</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_nxp_xpresso_11u14</configuration>
      </member>
      <member>
        <project>periph_bod</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_bod</project>
        <configuration>iflash_nxp_xpresso_11u14</configuration>
      </member>
      <member>
        <project>periph_ccan_rom</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_nxp_xpresso_11u14</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_nxp_xpresso_11u14</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_nxp_xpresso_11u14</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>iflash_nxp_xpresso_11u14</configuration>
      </member>
      <member>
        <project>periph_clkout</project>
        <configuration>iflash_nxp_xpresso_11c24</configuration>
      </member>
      <member>
        <project>periph_clkout</project>
        <configuration>iflash_nxp_xpresso_11u14</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


