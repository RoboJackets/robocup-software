# Keil uVision project periph_watchdog.uvproj, settings and files
target iflash_nxp_xpresso_11u14 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: watchdog_iflash_nxp_xpresso_11u14
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\board_common
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group src
    ../../../startup_code/: keil_startup_lpc11xx.s
    ./: watchdog.c
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_11xx/keil_output/nxp_xpresso_11u14/: board_nxp_xpresso_11u14.lib
    ../../../../../software/lpc_core/lpc_board/boards_11xx/keil_output/nxp_xpresso_11c24/: board_nxp_xpresso_11c24.lib
target iflash_nxp_xpresso_11c24 (ARM-ADS)
  device: LPC11C24/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: watchdog_iflash_nxp_xpresso_11c24
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11c24;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\board_common
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11c24
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
