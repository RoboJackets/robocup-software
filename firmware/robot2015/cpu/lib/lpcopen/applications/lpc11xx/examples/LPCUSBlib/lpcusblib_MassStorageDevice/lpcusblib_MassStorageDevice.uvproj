# Keil uVision project lpcusblib_MassStorageDevice.uvproj, settings and files
target iflash_nxp_xpresso_11u14 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MassStorage_iflash_nxp_xpresso_11u14 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __LPC11U1X__ CORE_M0 USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice\sdmmc
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: ..\..\..\tool_configs\keil_ini_files\LPC11U1x.sct
  group src
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: MassStorage.c Descriptors.c
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: SCSI.c fatutil.c DataRam.c
    ../../../startup_code/: keil_startup_lpc11xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_11xx/keil_output/nxp_xpresso_11u14/: board_nxp_xpresso_11u14.lib
    ../../../../../software/LPCUSBLib/Chips_Support/LPC11Uxx/keil_output/LPCUSBlib_LPC11U1x_Device/: LPCUSBlib_LPC11U1x_Device.lib
