# IAR project periph_watchdog.ewp, settings and files
configuration iflash_nxp_xpresso_11u14 (ARM)
  General.OGChipSelectEditMenu: LPC11U14FBD48_201 NXP LPC11U14FBD48_201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14
  OBJCOPY.OOCOutputFile: periph_watchdog.bin
  ILINK.IlinkOutputFile: watchdog_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iflash_nxp_xpresso_11c24 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC11C24FBD48_301 NXP LPC11C24FBD48_301
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11c24; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11c24
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_11xx/iar_output/nxp_xpresso_11c24/Exe/: board_nxp_xpresso_11c24.a
    ../../../../../software/lpc_core/lpc_board/boards_11xx/iar_output/nxp_xpresso_11u14/Exe/: board_nxp_xpresso_11u14.a
  group src
    ../../../startup_code/: iar_startup_lpc11xx.s
    ./: watchdog.c
