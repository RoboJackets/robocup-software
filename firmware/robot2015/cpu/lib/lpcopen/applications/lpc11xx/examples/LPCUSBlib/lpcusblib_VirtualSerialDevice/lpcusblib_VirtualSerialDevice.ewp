# IAR project lpcusblib_VirtualSerialDevice.ewp, settings and files
configuration iflash_nxp_xpresso_11u14 (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U14FBD48_201 NXP LPC11U14FBD48_201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0; __LPC11U1X__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_xpresso_11u14
  OBJCOPY.OOCOutputFile: lpcusblib_VirtualSerialDevice.srec
  prebuild: cmd /C /E:ON mkdir settings || cd
  ILINK.IlinkOutputFile: VirtualSerialDevice_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_11xx/iar_output/nxp_xpresso_11u14/Exe/: board_nxp_xpresso_11u14.a
    ../../../../../software/LPCUSBLib/Chips_Support/LPC11Uxx/iar_output/LPC11U1x_Device/Exe/: LPCUSBlib_LPC11U1x_Device.a
  group src
    ../../../../LPCUSBlib/lpcusblib_VirtualSerialDevice/: Descriptors.c VirtualSerial.c
    ../../../startup_code/: iar_startup_lpc11xx.s
    ../../../../LPCUSBlib/lpcusblib_VirtualSerialDevice/Lib/: UsbRom.c
