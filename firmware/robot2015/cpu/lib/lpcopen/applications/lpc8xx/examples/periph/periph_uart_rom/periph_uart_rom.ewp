# IAR project periph_uart_rom.ewp, settings and files
configuration iflash_nxp_xpresso_812 (ARM)
  General.OGChipSelectEditMenu: LPC812M101 NXP LPC812M101
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_8xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_8xx\nxp_xpresso_812; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_8xx\nxp_xpresso_812
  OBJCOPY.OOCOutputFile: periph_uart_rom.bin
  ILINK.IlinkOutputFile: uart_rom_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_8xx/iar_output/nxp_xpresso_812/Exe/: board_nxp_xpresso_812.a
  group src
    ./: uart_rom.c
    ../../../startup_code/: iar_startup_lpc8xx.s
