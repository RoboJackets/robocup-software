# Keil uVision project periph_uart_rom.uvproj, settings and files
target iflash_nxp_xpresso_812 (ARM-ADS)
  device: LPC812M101 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: uart_rom_iflash_nxp_xpresso_812
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\..\..\software\lpc_core\lpc_board\boards_8xx\nxp_xpresso_812;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_chip\chip_8xx;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\board_common
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group src
    ../../../startup_code/: keil_startup_lpc8xx.s
    ./: uart_rom.c
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_8xx/keil_output/nxp_xpresso_812/: board_nxp_xpresso_812.lib
