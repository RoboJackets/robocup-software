# IAR project freertos_blinky.ewp, settings and files
configuration iflash_nxp_xpresso_812 (ARM)
  General.OGChipSelectEditMenu: LPC812M101 NXP LPC812M101
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_8xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_8xx\nxp_xpresso_812; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M0PLUS
  AARM.AUserIncludes: ..\..\..\..\..\software\lpc_core\lpc_board\boards_8xx\nxp_xpresso_812; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: freertos_blinky.bin
  ILINK.IlinkOutputFile: freertos_blinky_iflash_nxp_xpresso_812.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_2.c
    ../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_8xx/iar_output/nxp_xpresso_812/Exe/: board_nxp_xpresso_812.a
  group src
    ./: freertos_blinky.c
    ../startup_code/: iar_freertos_startup_lpc8xx.s
