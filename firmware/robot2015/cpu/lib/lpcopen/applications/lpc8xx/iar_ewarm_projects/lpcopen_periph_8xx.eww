<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_8xx\lib_lpc_boards_8xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_acmp\periph_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_bod\periph_bod.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_clkout\periph_clkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_crc\periph_crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_i2c\periph_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_mrt\periph_mrt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_spi\periph_spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_uart\periph_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_uart_rom\periph_uart_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_wkt\periph_wkt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_wwdt\periph_wwdt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_board_libs</name>
      <member>
        <project>lib_lpc_boards_8xx</project>
        <configuration>nxp_xpresso_812</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>All_libs_and_Examples</name>
      <member>
        <project>lib_lpc_boards_8xx</project>
        <configuration>nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_acmp</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_bod</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_crc</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_gpio</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_mrt</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_spi</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_uart_rom</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_wkt</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_wwdt</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>periph_clkout</project>
        <configuration>iflash_nxp_xpresso_812</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


