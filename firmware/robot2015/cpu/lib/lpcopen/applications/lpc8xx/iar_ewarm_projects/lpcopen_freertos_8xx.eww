<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_8xx\lib_lpc_boards_8xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\freertos\freertos_blinky\freertos_blinky.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_board_libs</name>
      <member>
        <project>lib_lpc_boards_8xx</project>
        <configuration>nxp_xpresso_812</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>All_libs_and_Examples</name>
      <member>
        <project>lib_lpc_boards_8xx</project>
        <configuration>nxp_xpresso_812</configuration>
      </member>
      <member>
        <project>freertos_blinky</project>
        <configuration>nxp_xpresso_812</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


