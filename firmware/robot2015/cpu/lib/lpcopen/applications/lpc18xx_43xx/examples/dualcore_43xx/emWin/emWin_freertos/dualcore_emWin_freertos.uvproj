# Keil uVision project dualcore_emWin_freertos.uvproj, settings and files
target iflash_keil_mcb_4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: emwin_iflash_keil_mcb_4357
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357;..\..\..\..\..\..\software\CMSIS;..\..\common;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;.\configs;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;.\emWin518_Config;..\..\..\..\..\..\software\emWin\emWin518_header
  memory RVCT4: ROM 0x1a000000 size 0x40000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  group common
    ../../common/: main.c ipc_msg.c ipc_example.c m0_ImageLoader.c
  group src
    ./: keil_startup_lpc43xx_m0.S keil_startup_lpc43xx_m4.S
    ../../Blinky/: dualcore_blinky.c
    ../emWin/: dualcore_emwin.c
    ./emWin518_Config/: GUI_X_FreeRTOS.c LCDConf.c GUIConf.c
  group libs
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357/: board_keil_mcb_4357.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357_m0/: board_keil_mcb_4357_m0.lib
    ../../../../../../software/emWin/emWin518_library/uVision_4/: emWin_518_Keil4_M0_LE.lib emWin_518_Keil4_M4_LE.lib
  group FreeRTOS_43xx_M4
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS_43xx_M0
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM0/: port_m0.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOS_lpc43xx_m0_Tick.c
  group FreeRTOS
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
target iflash_keil_mcb_4357_m0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: emwin_iflash_keil_mcb_4357_m0
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357;..\..\..\..\..\..\software\CMSIS;..\..\common;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM0;.\configs;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;.\emWin518_Config;..\..\..\..\..\..\software\emWin\emWin518_header
  memory RVCT4: ROM 0x1a040000 size 0x40000
  memory RVCT9: RAM 0x10080000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
