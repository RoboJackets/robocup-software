# Keil uVision project lwip_tcpecho_freertos.uvproj, settings and files
target spifi_hitex_eva_1850 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lwip_freertos_spifi_hitex_eva_1850
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\lwip_tcpecho_freertos
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: lwip_tcpecho_freertos.c
    ../../../../../software/lwip/contrib/apps/tcpecho/: tcpecho.c
    ../startup_code_freertos/: keil_freertos_startup_lpc18xx43xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_1850/: board_hitex_eva_1850.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_4350/: board_hitex_eva_4350.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_1857/: board_keil_mcb_1857.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357/: board_keil_mcb_4357.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_1830/: board_ngx_xplorer_1830.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_4330/: board_ngx_xplorer_4330.lib
  group FreeRTOS_18xx
    ../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_43xx
    ../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../software/freertos/freertos/Source/: croutine.c queue.c list.c tasks.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
  group LWIP
    ../../../../../software/lwip/lwip/src/core/: udp.c timers.c tcp_out.c tcp_in.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c dhcp.c def.c
    ../../../../../software/lwip/lwip/src/core/ipv4/: ip_frag.c ip_addr.c ip.c inet_chksum.c inet.c igmp.c icmp.c autoip.c
    ../../../../../software/lwip/lwip/src/netif/: etharp.c
    ../../../../../software/lwip/lwip/src/api/: tcpip.c sockets.c netifapi.c api_msg.c api_lib.c netdb.c err.c
  group lpclwip
    ../../../../../software/lwip/lpclwip/arch/: sys_arch_freertos.c lpc18xx_43xx_systick_arch.c lpc18xx_43xx_emac.c lpc_debug.c
    ../../../../../software/lwip/lwip/src/api/: netbuf.c
target spifi_hitex_eva_4350 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lwip_freertos_spifi_hitex_eva_4350
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\lwip_tcpecho_freertos
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_ngx_xplorer_1830 (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: as above
  output: lwip_freertos_spifi_ngx_xplorer_1830
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\lwip_tcpecho_freertos
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_ngx_xplorer_4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: lwip_freertos_spifi_ngx_xplorer_4330
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\lwip_tcpecho_freertos
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target iflash_keil_mcb_1857 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lwip_freertos_iflash_keil_mcb_1857
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\lwip_tcpecho_freertos
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT8: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target iflash_keil_mcb_4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lwip_freertos_iflash_keil_mcb_4357
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\lwip_tcpecho_freertos
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT8: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
