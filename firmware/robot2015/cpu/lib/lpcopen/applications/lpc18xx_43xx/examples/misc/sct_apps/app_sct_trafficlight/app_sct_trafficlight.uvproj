# Keil uVision project app_sct_trafficlight.uvproj, settings and files
target iflash_keil_mcb_1857 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: sct_tlight_iflash_keil_mcb_1857
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857;..\app_sct_trafficlight;.\keil_mcb_18574357
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../startup_code/: keil_startup_lpc18xx43xx.s
    ./: sct_trafficlight.c
    ./hitex_eva_18504350/: sct_fsm_hitex_eva_18504350.c
    ./keil_mcb_18574357/: sct_fsm_keil_mcb_18574357.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_1850/: board_hitex_eva_1850.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_4350/: board_hitex_eva_4350.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_1857/: board_keil_mcb_1857.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357/: board_keil_mcb_4357.lib
target iflash_keil_mcb_4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: sct_tlight_iflash_keil_mcb_4357
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357;..\app_sct_trafficlight;.\keil_mcb_18574357
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_hitex_eva_1850 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: sct_tlight_spifi_hitex_eva_1850
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850;.\hitex_eva_18504350;..\app_sct_trafficlight
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_hitex_eva_4350 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: sct_tlight_spifi_hitex_eva_4350
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350;..\app_sct_trafficlight;.\hitex_eva_18504350
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
