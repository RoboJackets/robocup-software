# Keil uVision project lpcusblib_MassStorageHost.uvproj, settings and files
target spifi_hitex_eva_1850 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MassStorageHost_spifi_hitex_eva_1850
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 wLevel=2
  c define: __LPC18XX__ CORE_M3 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group fatfs
    ../../../../../software/filesystems/fatfslpc/: fs_usb.c rtc.c
    ../../../../../software/filesystems/fatfs/src/: ff.c
  group src
    ../../../../LPCUSBlib/lpcusblib_MassStorageHost/: MassStorageHost.c
    ../startup_code/: keil_startup_lpc18xx43xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_1850/: board_hitex_eva_1850.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_4350/: board_hitex_eva_4350.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_4350_m0/: board_hitex_eva_4350_m0.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_1857/: board_keil_mcb_1857.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357/: board_keil_mcb_4357.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357_m0/: board_keil_mcb_4357_m0.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_1830/: board_ngx_xplorer_1830.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_4330/: board_ngx_xplorer_4330.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_4330_m0/: board_ngx_xplorer_4330_m0.lib
    ../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/keil_output/LPCUSBlib_LPC18xx_Host/: LPCUSBlib_LPC18xx_Host.lib
    ../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/keil_output/LPCUSBlib_LPC43xx_Host/: LPCUSBlib_LPC43xx_Host.lib
target spifi_hitex_eva_4350 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: MassStorageHost_spifi_hitex_eva_4350 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target iflash_keil_mcb_1857 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MassStorageHost_iflash_keil_mcb_1857 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC18XX__ CORE_M3 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target iflash_keil_mcb_4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: MassStorageHost_iflash_keil_mcb_4357 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_ngx_xplorer_1830 (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: as above
  output: MassStorageHost_spifi_ngx_xplorer_1830 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC18XX__ CORE_M3 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_ngx_xplorer_4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: MassStorageHost_spifi_ngx_xplorer_4330 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __LPC43XX__ CORE_M4 USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\software\CMSIS;..\..\..\..\..\software\LPCUSBLib\Drivers\USB;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\LPCUSBlib\lpcusblib_MassStorageHost
  asm define: NO_CRP
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
