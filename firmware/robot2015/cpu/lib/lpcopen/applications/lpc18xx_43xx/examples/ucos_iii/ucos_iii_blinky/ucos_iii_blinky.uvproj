# Keil uVision project ucos_iii_blinky.uvproj, settings and files
target spifi_hitex_eva_1850 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ucos_iii_blinky_spifi_hitex_eva_1850
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M3\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: ucos_iii_blinky.c
    ../startup_code/: keil_ucos_iii_startup_lpc18xx43xx.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_4330/: board_ngx_xplorer_4330.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_1830/: board_ngx_xplorer_1830.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357/: board_keil_mcb_4357.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_1857/: board_keil_mcb_1857.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_4350/: board_hitex_eva_4350.lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_1850/: board_hitex_eva_1850.lib
  group ucos_iii_18xx
    ../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s
    ../../../../../software/ucos_iii/Micrium/Software/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm
  group ucos_iii_43xx
    ../../../../../software/ucos_iii/Micrium/Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm
    ../../../../../software/ucos_iii/lpc_ucos_iii/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group ucos_iii
    ../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Source/: os_var.c os_tmr.c os_time.c os_tick.c os_task.c os_stat.c os_sem.c os_q.c os_prio.c os_pend_multi.c os_mutex.c os_msg.c os_mem.c os_int.c os_flag.c os_dbg.c os_core.c os_cfg_app.c
    ../../../../../software/ucos_iii/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../../../software/ucos_iii/lpc_ucos_iii/lpc18xx43xx_bsp/: cpu_bsp.c
target spifi_hitex_eva_4350 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: ucos_iii_blinky_spifi_hitex_eva_4350
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M4\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  asm define: CORE_M4
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target iflash_keil_mcb_1857 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ucos_iii_blinky_iflash_keil_mcb_1857
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M3\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target iflash_keil_mcb_4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: ucos_iii_blinky_iflash_keil_mcb_4357
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M4\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  asm define: CORE_M4
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_ngx_xplorer_1830 (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: as above
  output: ucos_iii_blinky_spifi_ngx_xplorer_1830
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M3\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_ngx_xplorer_4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: ucos_iii_blinky_spifi_ngx_xplorer_4330
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x14000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M3\RealView;.\ucos_iii_config;..\ucos_iii_blinky;..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  asm define: CORE_M4
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
