# IAR project periph_memtest.ewp, settings and files
configuration iram_keil_mcb_1857 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: periph_memtest.srec
  ILINK.IlinkOutputFile: memtest_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iram_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\software\CMSIS\CMSIS\Include
configuration iram_hitex_eva_1850 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ILINK.IlinkIcfFile: ..\..\..\tool_configs\iar_linker_scripts\lpc18xx_43xx_spifi_ldscript.icf
configuration iram_hitex_eva_4350 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\software\CMSIS\CMSIS\Include
  ILINK.IlinkIcfFile: as above
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_1850/Exe/: board_hitex_eva_1850.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_1857/Exe/: board_keil_mcb_1857.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_1830/Exe/: board_ngx_xplorer_1830.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
  group src
    ../../../startup_code/: iar_startup_lpc18xx43xx.s
    ../../../../../software/lpc_core/lpc_chip/chip_common/: mem_tests.c
    ./: memtest.c
