# IAR project freertos_blinky.ewp, settings and files
configuration spifi_ngx_xplorer_1830 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa050, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M3
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: freertos_blinky.srec
  ILINK.IlinkOutputFile: freertos_blinky_spifi_ngx_xplorer_1830.out
  ILINK.IlinkIcfFile: lpc18xx_43xx_spifi_ldscript.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  AARM.ADefines: CORE_M4
  ILINK.IlinkOutputFile: freertos_blinky_spifi_ngx_xplorer_4330.out
configuration spifi_hitex_eva_1850 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  ILINK.IlinkOutputFile: freertos_blinky_spifi_hitex_eva_1850.out
configuration spifi_hitex_eva_4350 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  AARM.ADefines: CORE_M4
  ILINK.IlinkOutputFile: freertos_blinky_spifi_hitex_eva_4350.out
configuration iflash_keil_mcb_1857 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  ILINK.IlinkOutputFile: freertos_blinky_iflash_keil_mcb_1857.out
  ILINK.IlinkIcfFile: lpc18xx_43xx_ldscript_iflash.icf
configuration iflash_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$
  AARM.ADefines: CORE_M4
  ILINK.IlinkOutputFile: freertos_blinky_iflash_keil_mcb_4357.out
  ILINK.IlinkIcfFile: lpc18xx_43xx_ldscript_iflash.icf
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
  group FreeRTOS_18xx
    ../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FreeRTOS_43xx
    ../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_1850/Exe/: board_hitex_eva_1850.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_1857/Exe/: board_keil_mcb_1857.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_1830/Exe/: board_ngx_xplorer_1830.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
  group src
    ./: freertos_blinky.c
    ../startup_code/: iar_freertos_startup_lpc18xx43xx.s
