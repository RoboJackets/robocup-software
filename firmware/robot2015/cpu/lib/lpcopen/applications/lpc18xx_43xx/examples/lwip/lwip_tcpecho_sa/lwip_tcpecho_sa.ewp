# IAR project lwip_tcpecho_sa.ewp, settings and files
configuration spifi_ngx_xplorer_1830 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ngx1830_lwip_tcpecho_sa.out
  ILINK.IlinkIcfFile: ..\..\..\tool_configs\iar_linker_scripts\lpc18xx_43xx_spifi_ldscript.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: lwip_tcpecho_sa.out
configuration spifi_hitex_eva_1850 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  OBJCOPY.OOCOutputFile: lwip_tcpecho_sa.srec
  ILINK.IlinkOutputFile: lwip_spifi_hitex_eva_1850.out
configuration spifi_hitex_eva_4350 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: lwip_spifi_hitex_eva_4350.out
configuration iflash_keil_mcb_1857 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: lwip_tcpecho_sa.out
  ILINK.IlinkIcfFile: ..\..\..\tool_configs\iar_linker_scripts\lpc18xx_43xx_ldscript_iflash.icf
configuration iflash_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: lwip_tcpecho_sa.srec
  ILINK.IlinkOutputFile: mcb4357_lwip_tcpecho_sa.out
  ILINK.IlinkIcfFile: as above
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_1850/Exe/: board_hitex_eva_1850.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_1857/Exe/: board_keil_mcb_1857.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_1830/Exe/: board_ngx_xplorer_1830.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
  group lpclwip
    ../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc18xx_43xx_systick_arch.c lpc_debug.c
  group lwip
    ../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../software/lwip/lwip/src/netif/: etharp.c
  group src
    ../../../../../software/lwip/contrib/apps/tcpecho_raw/: echo.c
    ../../../startup_code/: iar_startup_lpc18xx43xx.s
    ./: lwip_tcpecho_sa.c
