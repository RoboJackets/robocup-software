# IAR project dualcore_blinky.ewp, settings and files
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: configs; ..\common; ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: example_blinky.srec
  ILINK.IlinkOutputFile: blinky_spifi_ngx_xplorer_4330.out
  ILINK.IlinkIcfFile: configs\blinky_spifi_m4.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration spifi_ngx_xplorer_4330_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M0 NXP LPC4330_M0
  ICCARM.CCDefines: CORE_M0
  ILINK.IlinkOutputFile: blinky_spifi_ngx_xplorer_4330_m0.out
  ILINK.IlinkIcfFile: configs\blinky_spifi_m0.icf
configuration iflash_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCIncludePath2: configs; ..\common; ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357
  ILINK.IlinkOutputFile: blinky_iflash_keil_mcb_4357.out
  ILINK.IlinkIcfFile: configs\blinky_iflash_m4.icf
configuration iflash_keil_mcb_4357_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M0 NXP LPC4357_M0
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: blinky_iflash_keil_mcb_4357_m0.out
  ILINK.IlinkIcfFile: configs\blinky_iflash_m0.icf
configuration spifi_hitex_eva_4350 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCIncludePath2: configs; ..\common; ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350
  ILINK.IlinkOutputFile: blinky_spifi_hitex_eva_4350.out
configuration spifi_hitex_eva_4350_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: blinky_spifi_ngx_xplorer_4330_m0.out
  ILINK.IlinkIcfFile: configs\blinky_spifi_m0.icf
  group common
    ../common/: ipc_example.c ipc_msg.c m0_ImageLoader.c main.c
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350_m0/Exe/: board_hitex_eva_4350_m0.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357_m0/Exe/: board_keil_mcb_4357_m0.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330_m0/Exe/: board_ngx_xplorer_4330_m0.a
  group src
    ./: dualcore_blinky.c
    ../../../startup_code/: iar_startup_lpc18xx43xx.s iar_startup_lpc43xx_m0.s
