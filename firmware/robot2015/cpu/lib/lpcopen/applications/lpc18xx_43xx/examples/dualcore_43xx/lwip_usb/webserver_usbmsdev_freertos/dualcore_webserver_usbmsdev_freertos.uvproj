# Keil uVision project dualcore_webserver_usbmsdev_freertos.uvproj, settings and files
target spifi_ngx_xplorer_4330 (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: webserver_usbmsdev_spifi_ngx_xplorer_4330
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lpclwip\arch;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw;..\..\LPCUSBlib\usbmsdev;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB;.\configs;..\..\common;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  memory RVCT4: ROM 0x14000000 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x1000
  group common
    ../../common/: main.c ipc_msg.c ipc_example.c m0_ImageLoader.c
  group src
    ./: keil_startup_lpc43xx_m0.S keil_startup_lpc43xx_m4.S
    ../../Blinky/: dualcore_blinky.c
    ../../lwip/webserver_freertos/: netconn_fs.c
    ../../lwip/webserver/: lwip_fs.c dualcore_webserver.c
    ../../../../../../software/filesystems/fatfslpc/: fs_mem.c rtc.c
    ../../../../../../software/filesystems/fatfs/src/: ff.c
  group src_usbmsdev
    ../../LPCUSBlib/usbmsdev/: ramdisk.c usbmsdev.c
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: Descriptors.c
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: SCSI.c
  group lwip
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c netdb.c netifapi.c sockets.c tcpip.c err.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c timers.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c
  group lpclwip
    ../../../../../../software/lwip/lpclwip/arch/: sys_arch_freertos.c lpc18xx_43xx_systick_arch.c lpc18xx_43xx_emac.c lpc_debug.c
    ../../../../../../software/lwip/lwip/src/api/: netbuf.c
  group freertos
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM0/: port_m0.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOS_lpc43xx_m0_Tick.c FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_4350/: board_hitex_eva_4350.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/hitex_eva_4350_m0/: board_hitex_eva_4350_m0.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357/: board_keil_mcb_4357.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_4357_m0/: board_keil_mcb_4357_m0.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_4330/: board_ngx_xplorer_4330.lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/ngx_xplorer_4330_m0/: board_ngx_xplorer_4330_m0.lib
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/keil_output/LPCUSBlib_LPC43xx_Device/: LPCUSBlib_LPC43xx_Device.lib
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/keil_output/LPCUSBlib_LPC43xx_Device_m0/: LPCUSBlib_LPC43xx_Device_m0.lib
target spifi_ngx_xplorer_4330_m0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: webserver_usbmsdev_spifi_ngx_xplorer_4330_m0
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lpclwip\arch;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw;..\..\LPCUSBlib\usbmsdev;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB;.\configs;..\..\common;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  memory RVCT4: ROM 0x14040000 size 0x40000
  memory RVCT9: RAM 0x10010000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target iflash_keil_mcb_4357 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: webserver_usbmsdev_iflash_keil_mcb_4357
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lpclwip\arch;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw;..\..\LPCUSBlib\usbmsdev;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB;.\configs;..\..\common;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
target iflash_keil_mcb_4357_m0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: webserver_usbmsdev_iflash_keil_mcb_4357_m0
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lpclwip\arch;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw;..\..\LPCUSBlib\usbmsdev;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB;.\configs;..\..\common;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  memory RVCT4: ROM 0x1a040000 size 0x40000
  memory RVCT9: RAM 0x10080000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
target spifi_hitex_eva_4350 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: webserver_usbmsdev_spifi_hitex_eva_4350
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lpclwip\arch;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw;..\..\LPCUSBlib\usbmsdev;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB;.\configs;..\..\common;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  memory RVCT4: ROM 0x14000000 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
target spifi_hitex_eva_4350_m0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: webserver_usbmsdev_spifi_hitex_eva_4350_m0
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lpclwip\arch;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver;..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw;..\..\LPCUSBlib\usbmsdev;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB;.\configs;..\..\common;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  memory RVCT4: ROM 0x14040000 size 0x40000
  memory RVCT9: RAM 0x10080000 size 0x10000
