# IAR project dualcore_usbmsdev_freertos.ewp, settings and files
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\usbmsdev; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  AARM.AUserIncludes: configs
  OBJCOPY.OOCOutputFile: example_MassStorageDevice.srec
  ILINK.IlinkOutputFile: usbmsdev_spifi_ngx_xplorer_4330.out
  ILINK.IlinkIcfFile: configs\usbdev_spifi_m4.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration spifi_ngx_xplorer_4330_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M0 NXP LPC4330_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\usbmsdev; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: usbmsdev_spifi_ngx_xplorer_4330_m0.out
  ILINK.IlinkIcfFile: configs\usbdev_spifi_m0.icf
configuration iflash_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\usbmsdev; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  ILINK.IlinkOutputFile: usbmsdev_iflash_keil_mcb_4357.out
  ILINK.IlinkIcfFile: configs\usbdev_iflash_m4.icf
configuration iflash_keil_mcb_4357_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M0 NXP LPC4357_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\usbmsdev; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: usbmsdev_iflash_keil_mcb_4357_m0.out
  ILINK.IlinkIcfFile: configs\usbdev_iflash_m0.icf
configuration spifi_hitex_eva_4350 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\usbmsdev; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  ILINK.IlinkOutputFile: usbmsdev_spifi_hitex_eva_4350.out
configuration spifi_hitex_eva_4350_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\usbmsdev; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: usbmsdev_spifi_ngx_xplorer_4330_m0.out
  ILINK.IlinkIcfFile: configs\usbdev_spifi_m0.icf
  group common
    ../../common/: ipc_example.c ipc_msg.c m0_ImageLoader.c main.c
  group freertos
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
  group freertos/port_m0
    ../../../../../../software/freertos/freertoslpc/: FreeRTOS_lpc43xx_m0_Tick.c
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group freertos/port_m4
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350_m0/Exe/: board_hitex_eva_4350_m0.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357_m0/Exe/: board_keil_mcb_4357_m0.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330_m0/Exe/: board_ngx_xplorer_4330_m0.a
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device/Exe/: LPCUSBlib_LPC43xx_Device.a
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device_m0/Exe/: LPCUSBlib_LPC43xx_Device_m0.a
  group src
    ../../Blinky/: dualcore_blinky.c
    ../../../../startup_code/: iar_startup_lpc18xx43xx.S iar_startup_lpc43xx_m0.S
  group src/massstorage
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: Descriptors.c
    ../usbmsdev/: ramdisk.c usbmsdev.c
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: SCSI.c
