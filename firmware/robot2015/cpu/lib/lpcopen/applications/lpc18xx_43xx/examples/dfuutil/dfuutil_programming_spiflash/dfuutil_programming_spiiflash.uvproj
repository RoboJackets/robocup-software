# Keil uVision project dfuutil_programming_spiiflash.uvproj, settings and files
target iram_dfu_util_spiflash (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: iram_dfu_util_spiflash +hex
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\software\spifilib\include;..\..\..\..\..\software\lpc_core\lpc_ip;..\..\..\..\..\software\lpc_core\lpc_ip\usbd_rom;..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357;..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857;..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\software\LPCUSBLib\Drivers\USB\Core\DCD\USBRom;..\dfuutil_common
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x20002000 size 0x2000
  link misc: --datacompressor off
  group startup
    ../dfuutil_common/: keil_dfuutl_startup_lpc18xx43xx.s
    ./: dfuutil_programming_spiiflash_systeminit.c
  group DFUUtil_Programming
    ../dfuutil_common/: dfuutil_programming_dfu_usbdesc.c dfuutil_programming_dfu_ops.c
  group DFUUtil_programming_algorithm
    ./: dfuutil_programming_spiflash_algorithm.c
  group libs
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/keil_output/keil_mcb_1857/: board_keil_mcb_1857.lib
    ../../../../../software/spifilib/lib/: spifi_drv_M3.lib
