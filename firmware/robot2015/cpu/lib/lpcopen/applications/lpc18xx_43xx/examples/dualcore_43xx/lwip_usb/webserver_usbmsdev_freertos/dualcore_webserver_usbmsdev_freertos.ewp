# IAR project dualcore_webserver_usbmsdev_freertos.ewp, settings and files
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lpclwip\arch; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\LPCUSBlib\usbmsdev; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  AARM.AUserIncludes: configs
  OBJCOPY.OOCOutputFile: example_lwip.srec
  ILINK.IlinkOutputFile: webserver_usbmsdev_spifi_ngx_xplorer_4330.out
  ILINK.IlinkIcfFile: configs\lwipusb_spifi_m4.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration spifi_ngx_xplorer_4330_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M0 NXP LPC4330_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lpclwip\arch; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\LPCUSBlib\usbmsdev; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: webserver_usbmsdev_spifi_ngx_xplorer_4330_m0.out
  ILINK.IlinkIcfFile: configs\lwipusb_spifi_m0.icf
configuration iflash_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lpclwip\arch; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\LPCUSBlib\usbmsdev; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  ILINK.IlinkOutputFile: webserver_usbmsdev_iflash_keil_mcb_4357.out
  ILINK.IlinkIcfFile: configs\lwipusb_iflash_m4.icf
configuration iflash_keil_mcb_4357_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M0 NXP LPC4357_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lpclwip\arch; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\LPCUSBlib\usbmsdev; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: webserver_usbmsdev_iflash_keil_mcb_4357_m0.out
  ILINK.IlinkIcfFile: configs\lwipusb_iflash_m0.icf
configuration spifi_hitex_eva_4350 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lpclwip\arch; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\LPCUSBlib\usbmsdev; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  ILINK.IlinkOutputFile: webserver_usbmsdev_spifi_hitex_eva_4350.out
configuration spifi_hitex_eva_4350_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lpclwip\arch; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\LPCUSBlib\usbmsdev; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: webserver_usbmsdev_spifi_ngx_xplorer_4330_m0.out
  ILINK.IlinkIcfFile: configs\lwipusb_spifi_m0.icf
  group common
    ../../common/: ipc_example.c ipc_msg.c m0_ImageLoader.c main.c
  group freertos
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
  group freertos/port_m0
    ../../../../../../software/freertos/freertoslpc/: FreeRTOS_lpc43xx_m0_Tick.c
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group freertos/port_m4
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350_m0/Exe/: board_hitex_eva_4350_m0.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357_m0/Exe/: board_keil_mcb_4357_m0.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330_m0/Exe/: board_ngx_xplorer_4330_m0.a
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device/Exe/: LPCUSBlib_LPC43xx_Device.a
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device_m0/Exe/: LPCUSBlib_LPC43xx_Device_m0.a
  group lpclwip
    ../../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc_debug.c sys_arch_freertos.c
  group lwip
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c ethernetif.c
  group src
    ../../Blinky/: dualcore_blinky.c
    ../../../../startup_code/: iar_startup_lpc18xx43xx.S iar_startup_lpc43xx_m0.S
  group src/lwip
    ../../lwip/webserver/: dualcore_webserver.c lwip_fs.c
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../../software/filesystems/fatfslpc/: fs_mem.c rtc.c
    ../../lwip/webserver_freertos/: netconn_fs.c
  group src/massstorage
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: Descriptors.c
    ../../LPCUSBlib/usbmsdev/: ramdisk.c usbmsdev.c
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: SCSI.c
