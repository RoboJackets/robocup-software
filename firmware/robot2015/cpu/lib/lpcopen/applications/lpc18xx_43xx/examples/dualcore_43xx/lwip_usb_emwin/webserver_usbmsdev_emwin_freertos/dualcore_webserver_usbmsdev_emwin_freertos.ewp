# IAR project dualcore_webserver_usbmsdev_emwin_freertos.ewp, settings and files
configuration iflash_keil_mcb_4357 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lpclwip\arch; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\LPCUSBlib\usbmsdev; ..\..\emWin\emWin\emWin518_Config; ..\..\..\..\..\..\software\emWin\emWin518_header; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  AARM.AUserIncludes: configs
  OBJCOPY.OOCOutputFile: dualcore_lwip_usb_emwin.srec
  ILINK.IlinkOutputFile: webserver_usbmsdev_emwin_iflash_keil_mcb_4357.out
  ILINK.IlinkIcfFile: configs\lwipusbemwin_iflash_m4.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration iflash_keil_mcb_4357_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M0 NXP LPC4357_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lpclwip\arch; ..\..\..\..\..\..\software\lwip\contrib\apps\httpserver_raw; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\LPCUSBlib\usbmsdev; ..\..\emWin\emWin\emWin518_Config; ..\..\..\..\..\..\software\emWin\emWin518_header; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: webserver_usbmsdev_emwin_iflash_keil_mcb_4357_m0.out
  ILINK.IlinkIcfFile: configs\lwipusbemwin_iflash_m0.icf
  group common
    ../../common/: ipc_example.c ipc_msg.c m0_ImageLoader.c main.c
  group freertos
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
  group freertos/port_m0
    ../../../../../../software/freertos/freertoslpc/: FreeRTOS_lpc43xx_m0_Tick.c
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group freertos/port_m4
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357_m0/Exe/: board_keil_mcb_4357_m0.a
    ../../../../../../software/emWin/emWin518_library/EmbeddedWorkbench_6/: emWin_518_IAR640_M0_LE.a emWin_518_IAR650_M4_LE.a
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device/Exe/: LPCUSBlib_LPC43xx_Device.a
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device_m0/Exe/: LPCUSBlib_LPC43xx_Device_m0.a
  group lpclwip
    ../../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc_debug.c sys_arch_freertos.c
  group lwip
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c ethernetif.c
  group src
    ../../Blinky/: dualcore_blinky.c
    ../../../../startup_code/: iar_startup_lpc18xx43xx.S iar_startup_lpc43xx_m0.S
  group src/emwin
    ../../emWin/emWin/: dualcore_emwin.c
    ../../emWin/emWin_freertos/emWin518_Config/: GUI_X_FreeRTOS.c GUIConf.c LCDConf.c
  group src/lwip
    ../../lwip/webserver/: dualcore_webserver.c lwip_fs.c
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../../software/filesystems/fatfslpc/: fs_mem.c rtc.c
    ../../lwip/webserver_freertos/: netconn_fs.c
  group src/massstorage
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: Descriptors.c
    ../../LPCUSBlib/usbmsdev/: ramdisk.c usbmsdev.c
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: SCSI.c
