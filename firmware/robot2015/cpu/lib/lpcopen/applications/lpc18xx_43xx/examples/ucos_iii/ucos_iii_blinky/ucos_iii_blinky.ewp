# IAR project ucos_iii_blinky.ewp, settings and files
configuration spifi_ngx_xplorer_1830 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa050, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ucos_iii_config; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ucos_iii_blinky.srec
  ILINK.IlinkOutputFile: blinky_spifi_ngx_xplorer_1830.out
  ILINK.IlinkIcfFile: ucos_iii_config\lpc18xx_43xx_spifi_ldscript.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ucos_iii_config; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  ILINK.IlinkOutputFile: blinky_spifi_ngx_xplorer_4330.out
configuration spifi_hitex_eva_1850 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ucos_iii_config; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  ILINK.IlinkOutputFile: blinky_spifi_hitex_eva_1850.out
configuration spifi_hitex_eva_4350 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ucos_iii_config; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  ILINK.IlinkOutputFile: blinky_spifi_hitex_eva_4350.out
configuration iflash_keil_mcb_1857 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ucos_iii_config; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  ILINK.IlinkOutputFile: blinky_iflash_keil_mcb_1857.out
  ILINK.IlinkIcfFile: ucos_iii_config\lpc18xx_43xx_ldscript_iflash.icf
configuration iflash_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ucos_iii_config; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB
  ILINK.IlinkOutputFile: blinky_iflash_keil_mcb_4357.out
  ILINK.IlinkIcfFile: ucos_iii_config\lpc18xx_43xx_ldscript_iflash.icf
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_1850/Exe/: board_hitex_eva_1850.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_1857/Exe/: board_keil_mcb_1857.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_1830/Exe/: board_ngx_xplorer_1830.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
  group src
    ../startup_code/: iar_ucos_iii_startup_lpc18xx43xx.s
    ./: ucos_iii_blinky.c
  group ucos_iii
    ../../../../../software/ucos_iii/lpc_ucos_iii/lpc18xx43xx_bsp/: cpu_bsp.c
    ../../../../../software/ucos_iii/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucos_iii_lpc18xx
    ../../../../../software/ucos_iii/lpc_ucos_iii/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm
    ../../../../../software/ucos_iii/lpc_ucos_iii/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.s os_cpu_c.c
  group ucos_iii_lpc43xx
    ../../../../../software/ucos_iii/lpc_ucos_iii/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm
    ../../../../../software/ucos_iii/lpc_ucos_iii/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.s os_cpu_c.c
