# IAR project lpcusblib_MassStorageDevice.ewp, settings and files
configuration spifi_ngx_xplorer_1830 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; __LPC18XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB; ..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice\sdmmc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lpcusblib_MassStorageDevice.srec
  ILINK.IlinkOutputFile: MassStorageDevice_spifi_ngx_xplorer_1830.out
  ILINK.IlinkIcfFile: ..\..\..\tool_configs\iar_linker_scripts\lpc18xx_43xx_spifi_usblib_ldscript.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB
  ILINK.IlinkOutputFile: MassStorageDevice_spifi_ngx_xplorer_4330.out
configuration iflash_keil_mcb_1857 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB
  ILINK.IlinkOutputFile: MassStorageDevice_iflash_keil_mcb_1857.out
configuration iflash_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB; ..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice\sdmmc
  ILINK.IlinkOutputFile: MassStorageDevice_iflash_keil_mcb_4357.out
configuration spifi_hitex_eva_1850 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB
  ILINK.IlinkOutputFile: MassStorageDevice_spifi_hitex_eva_1850.out
configuration spifi_hitex_eva_4350 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\LPCUSBlib\Drivers\USB
  ILINK.IlinkOutputFile: MassStorageDevice_spifi_hitex_eva_4350.out
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_1850/Exe/: board_hitex_eva_1850.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_1857/Exe/: board_keil_mcb_1857.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_1830/Exe/: board_ngx_xplorer_1830.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
    ../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC18xx_Device/Exe/: LPCUSBlib_LPC18xx_Device.a
    ../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device/Exe/: LPCUSBlib_LPC43xx_Device.a
  group src
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: DataRam.c fatutil.c SCSI.c UsbRom.c
    ../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: Descriptors.c MassStorage.c
    ../../../startup_code/: iar_startup_lpc18xx43xx.s
