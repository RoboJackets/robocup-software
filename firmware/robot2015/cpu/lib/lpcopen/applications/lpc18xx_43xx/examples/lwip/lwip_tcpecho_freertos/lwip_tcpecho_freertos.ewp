# IAR project lwip_tcpecho_freertos.ewp, settings and files
configuration iflash_keil_mcb_4357 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\netif; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\lpclwip\arch
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: lwip_tcpecho_freertos.srec
  ILINK.IlinkOutputFile: lwip_iflash_keil_mcb_4357.out
  ILINK.IlinkIcfFile: linkscripts\lpc18xx_43xx_ldscript_iflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration iflash_keil_mcb_1857 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\netif; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\lpclwip\arch
  AARM.ADefines: CORE_M3
  ILINK.IlinkOutputFile: lwip_iflash_keil_mcb_1857.out
configuration spifi_hitex_eva_4350 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\netif; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\lpclwip\arch
  ILINK.IlinkOutputFile: lwip_spifi_hitex_eva_4350.out
  ILINK.IlinkIcfFile: linkscripts\lpc18xx_43xx_spifi_ldscript.icf
configuration spifi_hitex_eva_1850 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\netif; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\lpclwip\arch
  AARM.ADefines: CORE_M3
  ILINK.IlinkOutputFile: lwip_spifi_hitex_eva_1850.out
  ILINK.IlinkIcfFile: linkscripts\lpc18xx_43xx_spifi_ldscript.icf
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\software\freertos\freertoslpc; $PROJ_DIR$; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\netif; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\lpclwip\arch
  ILINK.IlinkOutputFile: lwip_spifi_ngx_xplorer_4330.out
  ILINK.IlinkIcfFile: linkscripts\lpc18xx_43xx_spifi_ldscript.icf
configuration spifi_ngx_xplorer_1830 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830; ..\..\..\..\..\software\CMSIS\CMSIS\Include; $PROJ_DIR$; ..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\software\freertos\freertoslpc; ..\..\..\..\..\software\lwip\contrib\apps\tcpecho; ..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\software\lwip\lwip\src\include\netif; ..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\software\lwip\lpclwip\arch
  AARM.ADefines: CORE_M3
  ILINK.IlinkOutputFile: lwip_spifi_ngx_xplorer_1830.out
  ILINK.IlinkIcfFile: linkscripts\lpc18xx_43xx_spifi_ldscript.icf
  group FreeRTOS
    ../../../../../software/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c
    ../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
  group FreeRTOS_43xx
    ../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOS_lpc18xx
    ../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_1850/Exe/: board_hitex_eva_1850.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_1857/Exe/: board_keil_mcb_1857.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_1830/Exe/: board_ngx_xplorer_1830.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
  group lpclwip
    ../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc18xx_43xx_systick_arch.c lpc_debug.c sys_arch_freertos.c
  group LWIP
    ../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../software/lwip/lwip/src/netif/: etharp.c
  group src
    ../startup_code_freertos/: iar_freertos_startup_lpc18xx43xx.s
    ./: lwip_tcpecho_freertos.c
    ../../../../../software/lwip/contrib/apps/tcpecho/: tcpecho.c
