# IAR project dualcore_usbmsdev_ucosiii.ewp, settings and files
configuration spifi_ngx_xplorer_4330 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\usbmsdev\Lib; ..\usbmsdev; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  AARM.AUserIncludes: configs
  OBJCOPY.OOCOutputFile: example_MassStorageDevice.srec
  ILINK.IlinkOutputFile: usbmsdev_spifi_ngx_xplorer_4330.out
  ILINK.IlinkIcfFile: configs\usbdev_spifi_m4.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration spifi_ngx_xplorer_4330_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M0 NXP LPC4330_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\usbmsdev\Lib; ..\usbmsdev; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M0\IAR; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M0\Generic\IAR; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: usbmsdev_spifi_ngx_xplorer_4330_m0.out
  ILINK.IlinkIcfFile: configs\usbdev_spifi_m0.icf
configuration iflash_keil_mcb_4357 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\usbmsdev\Lib; ..\usbmsdev; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  OBJCOPY.OOCOutputFile: dualcore_usbmsdev_ucosiii.srec
  ILINK.IlinkOutputFile: usbmsdev_iflash_keil_mcb_4357.out
  ILINK.IlinkIcfFile: configs\usbdev_iflash_m4.icf
configuration iflash_keil_mcb_4357_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M0 NXP LPC4357_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\usbmsdev\Lib; ..\usbmsdev; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M0\IAR; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M0\Generic\IAR; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  ILINK.IlinkOutputFile: usbmsdev_iflash_keil_mcb_4357_m0.out
  ILINK.IlinkIcfFile: configs\usbdev_iflash_m0.icf
configuration spifi_hitex_eva_4350 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\usbmsdev\Lib; ..\usbmsdev; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  OBJCOPY.OOCOutputFile: dualcore_usbmsdev_ucosiii.srec
  ILINK.IlinkOutputFile: usbmsdev_spifi_hitex_eva_4350.out
configuration spifi_hitex_eva_4350_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: configs; ..\..\common; ..\..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\usbmsdev\Lib; ..\usbmsdev; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M0\IAR; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M0\Generic\IAR; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\LPCUSBlib\lpcusblib_MassStorageDevice
  AARM.ADefines: CORE_M0
  OBJCOPY.OOCOutputFile: dualcore_usbmsdev_ucosiii.srec
  ILINK.IlinkOutputFile: usbmsdev_spifi_ngx_xplorer_4330_m0.out
  ILINK.IlinkIcfFile: configs\usbdev_spifi_m0.icf
  group common
    ../../common/: iar_ucosiii_hook.S ipc_example.c ipc_msg.c m0_ImageLoader.c main.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350/Exe/: board_hitex_eva_4350.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/hitex_eva_4350_m0/Exe/: board_hitex_eva_4350_m0.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357_m0/Exe/: board_keil_mcb_4357_m0.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330/Exe/: board_ngx_xplorer_4330.a
    ../../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/ngx_xplorer_4330_m0/Exe/: board_ngx_xplorer_4330_m0.a
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device/Exe/: LPCUSBlib_LPC43xx_Device.a
    ../../../../../../software/LPCUSBLib/Chips_Support/LPC18xx_43xx/iar_output/LPC43xx_Device_m0/Exe/: LPCUSBlib_LPC43xx_Device_m0.a
  group src
    ../../Blinky/: dualcore_blinky.c
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s iar_startup_lpc43xx_m0.S
  group src/massstorage
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/: Descriptors.c
    ../usbmsdev/: ramdisk.c usbmsdev.c
    ../../../../../LPCUSBlib/lpcusblib_MassStorageDevice/Lib/: SCSI.c
  group ucosiii
    ../../../../../../software/ucos_iii/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucosiii/ucosiii_lpc43xx_m0
    ../../../../../../software/ucos_iii/lpc_ucos_iii/uC-CPU/ARM-Cortex-M0/IAR/: cpu_a_m0.asm
    ../../../../../../software/ucos_iii/lpc_ucos_iii/lpc18xx43xx_bsp/: cpu_bsp_lpc43xx_m0.c
    ../../../../../../software/ucos_iii/lpc_ucos_iii/uCOS-III/Ports/ARM-Cortex-M0/Generic/IAR/: os_cpu_a_m0.s os_cpu_c_m0.c
  group ucosiii/ucosiii_lpc43xx_m4
    ../../../../../../software/ucos_iii/lpc_ucos_iii/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm
    ../../../../../../software/ucos_iii/lpc_ucos_iii/lpc18xx43xx_bsp/: cpu_bsp.c
    ../../../../../../software/ucos_iii/lpc_ucos_iii/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.s os_cpu_c.c
