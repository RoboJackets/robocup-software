# IAR project example_emWin_with_touch.ewp, settings and files
configuration iflash_keil_mcb_4357 (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\..\..\software\CMSIS\CMSIS\Include; emWin518_Config; ..\..\..\..\..\software\emWin\emWin518_header
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: emwin_hello_world.srec
  ILINK.IlinkOutputFile: emwin_touch_iflash_keil_mcb_4357.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration iflash_keil_mcb_1857 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCIncludePath2: ..\..\..\..\..\software\lpc_core\lpc_ip; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857; ..\..\..\..\..\software\CMSIS\CMSIS\Include; emWin518_Config; ..\..\..\..\..\software\emWin\emWin518_header
  ILINK.IlinkOutputFile: emwin_touch_iflash_keil_mcb_1857.out
  group lib
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_1857/Exe/: board_keil_mcb_1857.a
    ../../../../../software/lpc_core/lpc_board/boards_18xx_43xx/iar_output/keil_mcb_4357/Exe/: board_keil_mcb_4357.a
    ../../../../../software/emWin/emWin518_library/EmbeddedWorkbench_6/: emWin_518_IAR650_M3_LE.a emWin_518_IAR650_M4_LE.a
  group src
    emWin518_Config/: GUI_X.c GUIConf.c LCDConf.c
    ../../../startup_code/: iar_startup_lpc18xx43xx.s
    ./: main.c TOUCH_Sample.c
