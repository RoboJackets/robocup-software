<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\lib_lpc_boards_18xx_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_adc\periph_adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_atimer\periph_atimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ccan\periph_ccan.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_dac\periph_dac.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_eeprom\periph_eeprom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ethernet\periph_ethernet.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_i2c\periph_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_i2s\periph_i2s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_lcd\periph_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_memtest\periph_memtest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ritimer\periph_ritimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_rtc\periph_rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_sdmmc\periph_sdmmc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_ssp\periph_ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_uart\periph_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\periph\periph_watchdog\periph_watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>board_libs_all</name>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330_m0</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>periph_ex_all</name>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_atimer</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_atimer</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_atimer</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_atimer</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_atimer</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_atimer</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_ccan</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_ccan</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_ccan</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_ccan</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_ccan</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_ccan</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_dac</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_dac</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_dac</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_dac</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_ethernet</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_i2c</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_lcd</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_lcd</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_lcd</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_lcd</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_memtest</project>
        <configuration>iram_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_memtest</project>
        <configuration>iram_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_memtest</project>
        <configuration>iram_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_memtest</project>
        <configuration>iram_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_ritimer</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_ritimer</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_ritimer</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_ritimer</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_ritimer</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_ritimer</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_sdmmc</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_sdmmc</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_sdmmc</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_sdmmc</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_sdmmc</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_sdmmc</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_ssp</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>periph_watchdog</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>periph_eeprom</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>periph_eeprom</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


