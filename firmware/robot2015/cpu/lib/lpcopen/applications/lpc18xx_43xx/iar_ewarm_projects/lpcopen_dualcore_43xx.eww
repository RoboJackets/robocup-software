<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\lib_lpc_boards_18xx_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\software\LPCUSBLib\Chips_Support\LPC18xx_43xx\lib_lpcusblib_18xx_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\Blinky\dualcore_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\blinky_freertos\dualcore_blinky_freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\blinky_ucosiii\dualcore_blinky_ucosiii.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\lwip\webserver\dualcore_webserver.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\lwip\webserver_freertos\dualcore_webserver_freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\LPCUSBlib\usbmsdev\dualcore_usbmsdev.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\LPCUSBlib\usbmsdev_freertos\dualcore_usbmsdev_freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\LPCUSBlib\usbmsdev_ucosiii\dualcore_usbmsdev_ucosiii.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\emWin\emWin\dualcore_emwin.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\emWin\emWin_freertos\dualcore_emwin_freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\lwip_usb\webserver_usbmsdev\dualcore_webserver_usbmsdev.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\lwip_usb\webserver_usbmsdev_freertos\dualcore_webserver_usbmsdev_freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\lwip_emwin\webserver_emwin\dualcore_webserver_emwin.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\lwip_emwin\webserver_emwin_freertos\dualcore_webserver_emwin_freertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\lwip_usb_emwin\webserver_usbmsdev_emwin\dualcore_webserver_usbmsdev_emwin.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\dualcore_43xx\lwip_usb_emwin\webserver_usbmsdev_emwin_freertos\dualcore_webserver_usbmsdev_emwin_freertos.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>lib_lpcusblib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib</project>
        <configuration>LPC43xx_Device_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_emwin</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_emwin</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_emwin</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_emwin</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_emwin_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_emwin_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_emwin</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_emwin</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_emwin_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_emwin_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>spifi_ngx_xplorer_4330</name>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>lib_lpcusblib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib</project>
        <configuration>LPC43xx_Device_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>spifi_ngx_xplorer_4330_m0</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>iflash_keil_mcb_4357</name>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>lib_lpcusblib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib</project>
        <configuration>LPC43xx_Device_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_emwin</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_emwin</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_emwin</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_emwin</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_emwin_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_emwin_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_emwin</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_emwin</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_emwin_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_emwin_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>iflash_keil_mcb_4357_m0</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>spifi_hitex_eva_4350</name>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>lib_lpcusblib</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib</project>
        <configuration>LPC43xx_Device_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_blinky</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_blinky_freertos</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_usbmsdev_freertos</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_webserver</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_webserver_freertos</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>dualcore_webserver_usbmsdev_freertos</project>
        <configuration>spifi_hitex_eva_4350_m0</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>libs_only</name>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_Device_m0</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


