<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\software\lpc_core\lpc_board\boards_18xx_43xx\lib_lpc_boards_18xx_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\software\LPCUSBLib\Chips_Support\LPC18xx_43xx\lib_lpcusblib_18xx_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_AudioInputDevice\lpcusblib_AudioInputDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_AudioOutputDevice\lpcusblib_AudioOutputDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_AudioOutputHost\lpcusblib_AudioOutputHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_GenericHIDDevice\lpcusblib_GenericHIDDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_KeyboardDevice\lpcusblib_KeyboardDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_KeyboardHost\lpcusblib_KeyboardHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_MassStorageDevice\lpcusblib_MassStorageDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_MassStorageHost\lpcusblib_MassStorageHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_MouseDevice\lpcusblib_MouseDevice.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_VirtualSerialandKeyboardHost\lpcusblib_VirtualSerialandKeyboardHost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\examples\LPCUSBlib\lpcusblib_VirtualSerial\lpcusblib_VirtualSerialDevice.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_board_libs</name>
      <member>
        <project>lib_lpc_board</project>
        <configuration>hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lib_lpc_board</project>
        <configuration>hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lib_lpc_board</project>
        <configuration>hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_board</project>
        <configuration>keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lib_lpc_board</project>
        <configuration>keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lib_lpc_board</project>
        <configuration>keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_board</project>
        <configuration>ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lib_lpc_board</project>
        <configuration>ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lib_lpc_board</project>
        <configuration>ngx_xplorer_4330_m0</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all_lpcusblib_libs</name>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC18xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC18xx_Host</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC18xx_HostDevice</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_Device_m0</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_Host</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_HostDevice</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>All_libraries_and_examples</name>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>hitex_eva_4350_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>keil_mcb_4357_m0</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lib_lpc_boards_18xx_43xx</project>
        <configuration>ngx_xplorer_4330_m0</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC18xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC18xx_Host</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC18xx_HostDevice</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_Device</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_Device_m0</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_Host</configuration>
      </member>
      <member>
        <project>lib_lpcusblib_18xx_43xx</project>
        <configuration>LPC43xx_HostDevice</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioInputDevice</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioInputDevice</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioInputDevice</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioInputDevice</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioInputDevice</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioInputDevice</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputDevice</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputDevice</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputDevice</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputDevice</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputDevice</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputDevice</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputHost</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputHost</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputHost</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputHost</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputHost</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_AudioOutputHost</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_GenericHIDDevice</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_GenericHIDDevice</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_GenericHIDDevice</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_GenericHIDDevice</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_GenericHIDDevice</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_GenericHIDDevice</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardDevice</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardDevice</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardDevice</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardDevice</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardDevice</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardDevice</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardHost</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardHost</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardHost</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardHost</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardHost</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_KeyboardHost</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageDevice</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageDevice</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageDevice</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageDevice</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageDevice</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageDevice</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageHost</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageHost</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageHost</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageHost</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageHost</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_MassStorageHost</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_MouseDevice</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_MouseDevice</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_MouseDevice</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_MouseDevice</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_MouseDevice</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_MouseDevice</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialandKeyboardHost</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialandKeyboardHost</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialandKeyboardHost</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialandKeyboardHost</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialandKeyboardHost</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialandKeyboardHost</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialDevice</project>
        <configuration>iflash_keil_mcb_1857</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialDevice</project>
        <configuration>iflash_keil_mcb_4357</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialDevice</project>
        <configuration>spifi_hitex_eva_1850</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialDevice</project>
        <configuration>spifi_hitex_eva_4350</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialDevice</project>
        <configuration>spifi_ngx_xplorer_1830</configuration>
      </member>
      <member>
        <project>lpcusblib_VirtualSerialDevice</project>
        <configuration>spifi_ngx_xplorer_4330</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


